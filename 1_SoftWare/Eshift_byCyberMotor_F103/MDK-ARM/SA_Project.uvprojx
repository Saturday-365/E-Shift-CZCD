# Keil uVision project SA_Project.uvprojx, settings and files
target SA_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: SA_Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Sourse_Library/1_SA_Library;../Sourse_Library/2_SA_peripheral;../Sourse_Library/3_SA_Starup;../Sourse_Library/4_XMCyberGear_Libary
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group SA_Library
    ../Sourse_Library/1_SA_Library/: SA_Delay.c SA_Delay.h SA_eulerangles.c SA_eulerangles.h SA_karman.c SA_karman.h SA_pid.c SA_pid.h SA_Usart.c SA_Usart.h SA_SoftIIC.c SA_SoftIIC.h SA_Key.c SA_Key.h SA_Flash.c SA_Flash.h
  group SA_CZCD
    ../Sourse_Library/1_SA_Library/: SA_CANDataprocess.c SA_CANDataprocess.h SA_E_Shift.c SA_E_Shift.h
  group SA_starup
    ../Sourse_Library/1_SA_Library/: headfile.h
    ../Sourse_Library/3_SA_Starup/: common.c common.h
  group XMCyberGear_Libary
    ../Sourse_Library/4_XMCyberGear_Libary/: xiaomi_driver.h pc_communication.c pc_communication.h CyberGear_Control.c CyberGear_Control.h CyberGear_Communication.c CyberGear_Communication.h
software components: CMSIS:CORE 4.3.0
